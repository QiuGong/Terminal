# Keil uVision project rtt.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtt +hex
  c flags: OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\RT-Thread\components\finsh;..\..\RT-Thread\include;..\..\RT-Thread\libcpu\arm\common;..\..\RT-Thread\libcpu\arm\cortex-m3;..\apps;..\apps\StartUp;..\apps\util;..\apps\rs485;..\apps\display;..\apps\aim900;..\apps\Warn;..\drivers;..\drivers\flash;..\drivers\uart;..\drivers\rtc;..\third_part\CMSIS\CM3\CoreSupport;..\third_part\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\third_part\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group cm3
    ../../RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group kernel
    ../apps/StartUp/: rtconfig.h
    ../../RT-Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Finsh
    ../../RT-Thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group STM32_StdPeriph
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../third_part/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ../apps/StartUp/: board.c stm32f10x_it.c startup.c
  group Apps
    ../apps/StartUp/: config.h
    ../apps/: application.c select_fun.c
  group Driver
    ../drivers/uart/: usart.c serial.c
    ../drivers/rtc/: ds1302.c rtc.c
  group Warn
    ../apps/Warn/: warn.h warn.c w_driver.c warn_judge_value.c warn_judge_timer.c warn_relate.c warn_time_out.c warn_power_drop.c
  group RS485
    ../apps/rs485/: rs485.h rs485.c rsRequest.c rsRespond.c sensor.c list.c
  group Display
    ../apps/display/: display.h display.c dspRequest.c dspRespond.c convert.c
  group Sim900
    ../apps/aim900/: app_sim900.c cellular.c sim900.c gsm_driver.c
  group FLASH
    ../drivers/flash/: flash.h data.c flash.c
  group Util
    ../apps/util/: util.h formula.c strLib.c ringbuffer.c
